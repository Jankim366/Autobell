# Keil uVision project WIFI.uvprojx, settings and files
target WIFI (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WIFI +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\USART;..\HARDWARE\LED;..\HARDWARE\STMFLASH;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\CMSIS;..\LIB\inc;..\CAR;..\HARDWARE\HX711;..\HARDWARE\HX711;..\SYSTEM\sys;..\HARDWARE\BEEP;..\HARDWARE\ESP8266
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../CMSIS/: startup_stm32f10x_hd.s
  group LIB
    ../LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_exti.c
    ../CMSIS/: system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/USART/: usart1.c usart2.c usart3.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/ESP8266/: esp8266.c
  group USER
    ../USER/: main.c stm32f10x_it.c adc.c communication.c keya.c leda.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_a.asm os_cpu_c.c os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
